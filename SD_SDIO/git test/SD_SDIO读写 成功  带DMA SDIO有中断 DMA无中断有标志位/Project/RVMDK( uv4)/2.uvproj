# Keil uVision project 2.uvproj, settings and files
target 2 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 2 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\FWlib\inc;..\..\libraries\FWlib\src;..\..\libraries\CMSIS\startup;..\RVMDK( uv4);..\..\User;..\..\User\usart;..\..\User\sdcard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group FWLB
    ../../libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c bsp_sdio_sdcard.c stm32f10x_sdio.c stm32f10x_dma.c
    ../../User/usart/: bsp_usart1.c
  group DOC
    ../../Doc/: readme.txt
